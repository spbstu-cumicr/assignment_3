# Keil uVision project project_for_keil_5.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: test
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_FULL_ASSERT, USE_STDPERIPH_DRIVER,  __FPU_PRESENT, __STDC_LIMIT_MACROS, USE_HSE, STM32F407xx, STM32F40_41xxx, HSE_VALUE=8000000
  c misc: --c99
  c include: .\src\cmsis;.\src;.\src\mcu_support_package\inc;.\src\spl\inc;.\src\spl
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group main
    ./src/main/: main.c led.c timer.c button.c variants.c lab_3_test.c lab_3_test.lib
  group msu_support_package
    ./src/mcu_support_package/: system_stm32f4xx.c
    ./src/mcu_support_package/arm/: startup_stm32f407xx.s
  group spl
    ./src/spl/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_tim.c stm32f4xx_rng.c
